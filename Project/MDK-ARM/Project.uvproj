# Keil uVision project Project.uvproj, settings and files
target DSB01 (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: DSB01 +hex
  AfterMake: D:\Program Files (x86)\Keil\ARM\BIN40\fromelf.exe --bin -o bin/DSB01.bin DSB01/DSB01.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_MD
  c include: ..\;..\..\Libraries\CMSIS\Device\ST\STM32L1xx\Include;..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc;..\..\Utilities\STM32_EVAL;..\..\Utilities\STM32_EVAL\Common;..\..\Utilities\STM32_EVAL\STM32L152D_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x2800
  link misc: --diag_suppress=L6329
  group User
    ../: main.c Weighing.c Board.c Text.c Filter.c Init.c Protocol_HBM.c Interface.c Parameter.c MyLib.c
  group AbstractionLayer
    ../: Pin.c ADC.c Uart.c Uart2.c Timer.c eeprom.c CS1237.c DS18B20.c MMA8451.c stm32l1xx_it.c
  group StdPeriph_Driver
    ../../Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_adc.c
  group CMSIS
    ../: system_stm32l1xx.c
  group Boot
    ../../Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/arm/: startup_stm32l1xx_md.s
  group Doc
    ./: readme.txt
